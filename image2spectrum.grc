options:
  parameters:
    author: Gary Schafer / Paul Maine
    generate_options: qt_gui
    id: image2spectrum
    output_language: python
    title: Image to Spectrum
  states: {}

blocks:
- name: dr
  id: variable
  parameters:
    comment: |-
      Desired dynamic
      range (dB)
    value: '40'
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: 'Value: 2**int(np.log(image_width)/np.log(2)+1)'
    value: 2**int(np.log(image_width)/np.log(2)+1)
  states: {}
- name: image_width
  id: variable
  parameters:
    value: '1600'
  states: {}
- name: max_level
  id: variable_qtgui_range
  parameters:
    comment: |-
      Use this to adjust the reference
      level of the waterfall sink.
    label: Maximum Spectrogram Level
    start: '-160'
    step: '1'
    stop: '70'
    value: '-38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: zero_high
  id: variable
  parameters:
    comment: 'Value: fft_size-image_width-zero_low'
    value: fft_size-image_width-zero_low
  states: {}
- name: zero_low
  id: variable
  parameters:
    comment: 'Value: int((fft_size-image_width)/2)'
    value: int((fft_size-image_width)/2)
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    comment: 'Sensitivity: np.pi/64'
    sensitivity: np.pi/64
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '64'
    minimum: '-64'
    seed: '0'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/Videos/Youtube/Lady-Maryland-1600pt-width-flipped.raw
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Constant: dr*np.log(10)/5100'
    const: dr*np.log(10)/5100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Constant: 10**(1-dr/20)'
    const: 10**(1.5-dr/20)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '15'
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: 'Lengths: (zero_low, image_width,zero_high)'
    lengths: (zero_low, image_width,zero_high)
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: exp
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/gary/Videos/Youtube/Spectrum-painting/Lady-Maryland-1600pt-width-flipped.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[1/fft_size,]*fft_size'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      GENERAL SETUP:
      * In the File Source block, select the desired file. NOTE: This
      should be a file representing a simple 2D array of 8-bit
      integers, which themselves represent a grayscale image.
      * Set the image width manually using the "image_width"
      variable above. For example, if the image is 850 pixels wide,
      set the value in this variable block to 850.
      * If desired, set the dynamic range using the "dr" variable
      above.

      IF OUTPUTTING TO A SDR:
      * In the File Source, set the "Repeat" value to "Yes".
      * Connect the SDR sink to the output of the "Vector to Stream"
      block and disable / delete the "Throttle" block.
      * Set the desired sample rate above.
      * Set your desired sample rate using the "samp_rate" variable.

      IF OUTPUTTING TO A WAV FILE:
      * In the File Source, set the "Repeat" value to "No".
      * Enable the "Complex to Float" and "WAV File Sink" blocks.
      * In the WAV File Sink block, set the output filename with
      the extension ".wav".
    note: General Instructions
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: fft_size
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: fft_size
    int_max: max_level
    int_min: max_level-dr
    type: complex
    update_time: '0.001'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_random_uniform_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_char_to_float_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_mux_0, '1']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '0']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0, '2']
- [blocks_repeat_0, '0', fft_vxx_0, '0']
- [blocks_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_repeat_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_transcendental_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle2_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
