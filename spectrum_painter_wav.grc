options:
  parameters:
    author: Gary Schafer / Paul Maine
    generate_options: qt_gui
    id: spectrum_painter
    output_language: python
    title: Spectrum Painter as .WAV File
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    comment: 2**(two_power+1)
    value: 2**(two_power+1)
  states: {}
- name: imageWidth
  id: variable
  parameters:
    value: '600'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: |-
      Put the input filename (including the
      .rf32 extension) here. Do not forget
      to put double quotes at each end:
      "yourInputFileHere.rf32"
    value: '"Eggbert_600_flipped-600pt-width.rf32"'
  states: {}
- name: input_folder
  id: variable
  parameters:
    comment: |-
      Put in the absolute directory path
      for the input and output files here:
      "/your/folder/here/"
      Do not forget to put the quotes at
      each end.
    value: '"/home/gary/Videos/Youtube/Spectrum-painting/"'
  states: {}
- name: outputGain
  id: variable
  parameters:
    comment: |-
      This will set the level of the
      output signal. The signal level
      should be such that it does
      not exceed +1. If it does,
      reduce the level until the
      output is less than 1.
    value: '-40'
  states: {}
- name: repeatVal
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: two_power
  id: variable
  parameters:
    value: int(np.log(imageWidth)/np.log(2))
  states: {}
- name: zeropad_left
  id: variable
  parameters:
    value: int((fft_size-imageWidth)/2)
  states: {}
- name: zeropad_right
  id: variable
  parameters:
    value: int(fft_size-imageWidth-zeropad_left)
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: np.pi/64
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_folder+input_file
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(outputGain/20)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Randomize the
      phase of each
      sample.
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '7'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      This increases the amount of time
      required to transmit the image
      for those receive systems that are
      slower.
    interp: repeatVal
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: |-
      Zeropad the ends of the
      spectrum to provide a
      power-of-2 length.
    lengths: (zeropad_left,imageWidth,zeropad_right)
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: |-
      The output file will be automatically
      set to be stored in the input_folder
      and using the same prefix as the
      input_file, but with the ".wav"
      extension.
    file: input_folder+__import__('os').path.splitext(input_file)[0]+".wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    comment: |-
      This will create a pseudorandom
      bitstream that will be used to
      create a randomized phase for
      each spectral point.
    degree: '31'
    mask: 2**30+2**24
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: |-
      Perform the inverse FFT on
      each line of the image.
    fft_size: fft_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[1,]*fft_size'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '20000'
    srate: samp_rate
    type: float
    update_time: '0.001'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '3'
    fc: '0'
    fftsize: fft_size
    int_max: '0'
    int_min: '-60'
    type: complex
    update_time: '0.01'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: vectored
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: vectored
  states: {}

connections:
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_mux_0, '1']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '2']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repeat_0, '0', fft_vxx_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_1, '0']
- [virtual_source_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
